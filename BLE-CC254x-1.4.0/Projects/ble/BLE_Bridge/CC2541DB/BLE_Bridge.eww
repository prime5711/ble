<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\BLE_Bridge.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>BLE_Bridge</project>
        <configuration>CC2541-SPI</configuration>
      </member>
      <member>
        <project>BLE_Bridge</project>
        <configuration>CC2541-UART</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


